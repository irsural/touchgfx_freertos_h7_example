<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\touchgfx_h7_template.ewp</path>
  </project>
  <batchBuild />
</workspace>
