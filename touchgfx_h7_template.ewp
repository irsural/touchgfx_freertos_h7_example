# IAR project touchgfx_h7_template.ewp, settings and files
configuration STM32H743I-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743XI ST STM32H743XI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: ST; USE_HAL_DRIVER; STM32H743xx
  ICCARM.CCIncludePath2: Core; TouchGFX/target/generated; TouchGFX/generated/texts/include; TouchGFX/generated/fonts/include; TouchGFX/generated/images/include; TouchGFX/generated/gui_generated/include; TouchGFX/gui/include; TouchGFX/target; ../extern_libs/st/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Inc; ../extern_libs/st/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Inc/Legacy; ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/include; ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2; ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F; ../extern_libs/st/STM32Cube_FW_H7\Middlewares/ST/TouchGFX/touchgfx/framework/include; ../extern_libs/st/STM32Cube_FW_H7/Drivers/CMSIS/Device/ST/STM32H7xx/Include; ../extern_libs/st/STM32Cube_FW_H7/Drivers/CMSIS/Include; ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/Common; ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/STM32H743I-EVAL; ..\extern_libs\st\STM32Cube_FW_H7\Middlewares\Third_Party\FatFs\src
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: Core
  OBJCOPY.OOCOutputFile: touchgfx_h7_template.hex
  ILINK.IlinkOutputFile: touchgfx_h7_template.out
  ILINK.IlinkIcfFile: stm32h743xx_flash.icf
  ILINK.IlinkAdditionalLibs: C:\TouchGFXProjects\MyApplication\Middlewares\ST\touchgfx\lib\core\cortex_m7\IAR8.x\touchgfx_core_release.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/exc7200/: exc7200.c exc7200_reg.c
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/mt25tl01g/: mt25tl01g.c
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/Components/wm8994/: wm8994.c wm8994_reg.c
  group Drivers/BSP/STM32H743I-EVAL
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_qspi.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c stm32h743i_eval_ts.c
  group Drivers/CMSIS
    Core/: system_stm32h7xx.c
  group Drivers/STM32H7xx_HAL_Driver
    ../extern_libs/st/STM32Cube_FW_H7/Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sdram.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group EWARM
    ./: startup_stm32h743xx.s stm32h743xx_flash.icf
  group FatFs
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FatFs/src/: diskio.c diskio.h ff.c ff.h ff_gen_drv.c ff_gen_drv.h
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group Middlewares/FreeRTOS
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
    ../extern_libs/st/STM32Cube_FW_H7/Middlewares/Third_Party/FreeRTOS/Source/include/: semphr.h
  group TouchGFX/fonts
    TouchGFX/generated/fonts/src/: ApplicationFontProvider.cpp CachedFont.cpp Font_verdana_10_4bpp_0.cpp Font_verdana_25_4bpp_0.cpp Font_verdana_30_4bpp_0.cpp Font_verdana_40_4bpp_0.cpp FontCache.cpp GeneratedFont.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_25_4bpp.cpp Kerning_verdana_30_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_25_4bpp.cpp Table_verdana_30_4bpp.cpp Table_verdana_40_4bpp.cpp UnmappedDataFont.cpp
    TouchGFX/generated/texts/src/: LanguageGb.cpp
  group TouchGFX/gui
    TouchGFX/gui/src/audioplayer_screen/: AudioPlayerPresenter.cpp AudioPlayerView.cpp
    TouchGFX/gui/src/common/: FrontendApplication.cpp
    TouchGFX/gui/include/gui/common/: FrontendApplication.hpp FrontendHeap.hpp
    TouchGFX/gui/src/containers/: ItemsListContainer.cpp TextContainer.cpp TextWithImageContainer.cpp
    TouchGFX/gui/src/model/: Model.cpp
    TouchGFX/gui/include/gui/model/: Model.hpp ModelListener.hpp
  group TouchGFX/gui_generated
    TouchGFX/generated/gui_generated/src/audioplayer_screen/: AudioPlayerViewBase.cpp
    TouchGFX/generated/gui_generated/include/gui_generated/audioplayer_screen/: AudioPlayerViewBase.hpp
    TouchGFX/generated/gui_generated/src/common/: FrontendApplicationBase.cpp
    TouchGFX/generated/gui_generated/src/containers/: ItemsListContainerBase.cpp TextContainerBase.cpp TextWithImageContainerBase.cpp
    TouchGFX/generated/gui_generated/include/gui_generated/containers/: ItemsListContainerBase.hpp TextContainerBase.hpp
  group TouchGFX/images
    TouchGFX/generated/images/src/: BitmapDatabase.cpp image_background.cpp image_close_button.cpp image_close_button_pressed.cpp image_info_icon.cpp image_modal_background.cpp image_my_modal_background.cpp image_play_image.cpp image_show_modal_button.cpp image_show_modal_button_pressed.cpp image_show_my_modal_button.cpp image_show_my_modal_button_pressed.cpp
    TouchGFX/generated/images/src/__designer/: image_Blue_Buttons_Round_icon_button.cpp image_Blue_Buttons_Round_icon_button_pressed.cpp image_Blue_Icons_Back_arrow_32.cpp image_Blue_Icons_Next_arrow_32.cpp image_Blue_Icons_Play_32.cpp image_Blue_Slider_Horizontal_Medium_Indicators_Slider_Round_nob.cpp image_Blue_Slider_Horizontal_Medium_Slider_Round_back.cpp image_Blue_Slider_Horizontal_Medium_Slider_Round_fill.cpp image_Blue_Textures_gplaypattern.cpp image_Blue_Textures_irongrip.cpp
  group TouchGFX/target
    TouchGFX/target/: CortexMMCUInstrumentation.cpp CortexMMCUInstrumentation.hpp STM32TouchController.cpp STM32TouchController.hpp TouchGFXGPIO.cpp TouchGFXHAL.cpp TouchGFXHAL.hpp
  group TouchGFX/target/generated
    TouchGFX/target/generated/: OSWrappers.cpp STM32DMA.cpp STM32DMA.hpp TouchGFXGeneratedHAL.cpp TouchGFXGeneratedHAL.hpp
  group TouchGFX/texts
    TouchGFX/generated/texts/src/: Texts.cpp TypedTextDatabase.cpp
  group User/configs
    Core/: exc7200_conf.h ffconf.h FreeRTOSConfig.h is42s32800g_conf.h mt25tl01g_conf.h stm32h743i_eval_conf.h stm32h7xx_hal_conf.h stmpe811_conf.h ts3510_conf.h
  group User/Core
    Core/: app.cpp app.h audio_play.cpp audio_play.h cfg.cpp cfg.h codecvt_oem866.cpp codecvt_oem866.h defs.h file_operations.cpp file_operations.h main.cpp sd_diskio_dma_rtos.c sd_diskio_dma_rtos.h stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c stm32h7xx_it.cpp stm32h7xx_it.h utils.h
  group User/Core/Threads
    Core/: play_wav_thread.cpp play_wav_thread.h read_dir_thread.cpp read_dir_thread.h thread.h touchgfx_thread.cpp touchgfx_thread.h
